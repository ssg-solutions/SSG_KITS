# Keil uVision project SD_MMC_INTERFACE.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: SD_MMC_INTERFACE +hex
  AfterMake: fromelf --bin .\SD_MMC_INTERFACE.axf -o .\SD_MMC_INTERFACE.bin
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s type.h mmcmain.c mmcmain.h spi_mmc.c spi_mmc.h
