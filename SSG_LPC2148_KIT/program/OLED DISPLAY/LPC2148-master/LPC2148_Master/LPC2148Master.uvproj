# Keil uVision project LPC2148Master.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: LPC2148Master +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\lib\adc;.\lib\delay;.\lib\gpio;.\lib\irq;.\lib\nstring;.\lib\serial;.\lib\system;.\modules\gsm;.\modules\lcd;.\modules\dht11;.\modules\hcsr04;.\lib\i2c;.\lib\spi;.\modules\mcp320x;.\lib\rtc;.\modules\ssd1306;.\modules\keypad;.\lib\extint;.\modules\nrf24;.\modules\mpu6050
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s
  group lib
    ./lib/adc/: adc.c
    ./lib/delay/: delay.c
    ./lib/gpio/: gpio.c
    ./lib/irq/: irq.c
    ./lib/nstring/: Nstring.c
    ./lib/serial/: serial.c
    ./lib/i2c/: i2c.c
    ./lib/spi/: spi.c
    ./lib/rtc/: rtc.c
    ./lib/extint/: extint.c
  group Main
    ./: main.c demo.c
  group modules
    ./modules/gsm/: gsm.c
    ./modules/lcd/: lcd.c
    ./modules/dht11/: dht11.c
    ./modules/hcsr04/: hcsr04.c
    ./modules/mcp320x/: mcp320x.c
    ./modules/SSD1306/: oled.c
    ./modules/keypad/: keypad.c
    ./modules/nrf24/: nrf24.c
    ./modules/mpu6050/: mpu6050.c
